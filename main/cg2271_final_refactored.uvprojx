# Keil uVision project cg2271_final_refactored.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: cg2271_final_refactored
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group motor_control
    ./: motor_control.h motor_control.c
  group led_control
    ./: led_control.c led_control.h
  group main
    ./: main.c common.h
  group audio_control
    ./: audio_control.c audio_control.h songs.h
  group uart_control
    ./: uart_control.h uart_control.c
  group custom_queue
    ./: custom_queue.h custom_queue.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:Startup 2.5.0
